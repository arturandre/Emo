# Repository arturandre/Emo

## KiCad design Circuit/EmoRobot/pcb/marta.kicad_pcb

Parts:
AE1: RFID Antenna; JST_XH_B02B-XH-A_02x2.50mm_Straight
D1: Power LED; JST_XH_B02B-XH-A_02x2.50mm_Straight
IC1: MPU6050 Gyro + Accelerometer; MPU6050
IC2: RaspberryPiZeroW; RaspberryPiZeroW_UpSideDown
IC3: PCM5102 Audio Stereo DAC; PCM5102
IC4: PAM8406 Audio Amplifier; PAM8406
IC5: RDM6300 RFID Reader; RDM6300
J1, J2: Conn_01x08; JST_XH_B08B-XH-A_08x2.50mm_Straight
J3: Conn_02x04_Odd_Even; Pin_Header_Straight_2x04_Pitch2.54mm
J4: GND; Pin_Header_Straight_1x04_Pitch2.54mm
J5: +3.3V; Pin_Header_Straight_1x04_Pitch2.54mm
J6: +5V; Pin_Header_Straight_1x04_Pitch2.54mm
LS1: Right Speaker; JST_XH_B02B-XH-A_02x2.50mm_Straight
LS2: Left Speaker; JST_XH_B02B-XH-A_02x2.50mm_Straight
R1: 2a; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R2: a; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R3: 220R; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R4: R; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
SW1: Reset Button; JST_XH_B02B-XH-A_02x2.50mm_Straight
SW2: ON/OFF Button; JST_XH_B02B-XH-A_02x2.50mm_Straight
SW3: GPIO 5; JST_XH_B02B-XH-A_02x2.50mm_Straight
SW4: GPIO 6; JST_XH_B02B-XH-A_02x2.50mm_Straight
SW5: GPIO 13; JST_XH_B02B-XH-A_02x2.50mm_Straight
SW6: GPIO 26; JST_XH_B02B-XH-A_02x2.50mm_Straight
U1: OnOffShim
U2: TCRT5000 IR Sensor; JST_XH_B04B-XH-A_04x2.50mm_Straight
U3: 74HCT245 Level Shifter; DIP-20_W7.62mm
U4: WS2812B; Pin_Header_Straight_1x03_Pitch2.54mm

Connections:
+3V3: IC2.1 (3.3V,DC_Power), J5.1, J5.2, J5.3, J5.4
+5V: IC1.1 (VCC), IC2.2 (DC_Power,5V), IC2.4 (DC_Power,5V), IC3.1 (VIN), IC4.1 (VCC), IC5.1 (VCC), J1.1, J2.8, J6.1, J6.2, J6.3, J6.4, R3.2, R4.2, U1.1 (+5V), U1.2 (+5V), U3.1 (DIR), U3.20 (VCC), U4.1 (5V_VCC)
GNDREF: D1.1 (K), IC1.2 (GND), IC2.6 (GND), IC2.9 (GND), IC2.14 (GND), IC2.20 (GND), IC2.25 (GND), IC2.30 (GND), IC2.34 (GND), IC2.39 (GND), IC3.2 (GND), IC4.2 (GND), IC5.2 (GND), J1.2, J2.7, J4.1, J4.2, J4.3, J4.4, R1.2, SW3.1, SW4.1, SW5.1, SW6.1, U1.3 (GND), U1.11 (GND), U2.1 (E), U2.3 (C), U3.10 (GND), U3.19 (NOT_OE), U4.3 (GND)
unnamed: AE1.1, IC5.9 (ANT)
unnamed: AE1.2, IC5.10 (ANT)
unnamed: D1.2 (A), R4.1
unnamed: IC1.3 (SCL), IC2.5 (GPIO_03,SCL1,I²C)
unnamed: IC1.4 (SDA), IC2.3 (GPIO_02,SDA1,I²C)
unnamed: IC1.8 (INT), IC2.13 (GPIO_27,GPIO_GEN2)
unnamed: IC2.7 (GPIO_04,GPIO_GCLK), U1.10 (Cut_Power)
unnamed: IC2.10 (RXD0,GPIO_15), R1.1, R2.2
unnamed: IC2.11 (GPIO_17,GPIO_GEN0), U1.12 (Trigger)
unnamed: IC2.12 (GPIO_GEN1,GPIO_18), IC3.5 (BCK)
unnamed: IC2.15 (GPIO_22,_GPIO_GEN3), J2.6
unnamed: IC2.16 (GPIO_GEN4,GPIO_23), J1.8
unnamed: IC2.17 (3.3V,DC_Power), J1.6, J2.5
unnamed: IC2.18 (GPIO_GEN5,GPIO_24), J1.7
unnamed: IC2.19 (GPIO_10,SPI_MOSI), J2.4
unnamed: IC2.21 (GPIO_09,SPI_MISO), J2.3
unnamed: IC2.22 (GPIO_GEN6,GPIO_25), J2.2
unnamed: IC2.23 (GPIO_11,SPI_CLK), J2.1
unnamed: IC2.24 (SPI_CE0_N,GPIO_08), J1.5
unnamed: IC2.26 (SPI_CE1_N,GPIO_07), J1.4
unnamed: IC2.29 (GPIO_05), SW3.2
unnamed: IC2.31 (GPIO_06), SW4.2
unnamed: IC2.32 (GPIO_12), U3.2 (A0)
unnamed: IC2.33 (GPIO_13), SW5.2
unnamed: IC2.35 (GPIO_19), IC3.3 (LRCK)
unnamed: IC2.36 (GPIO_16), J1.3
unnamed: IC2.37 (GPIO_26), SW6.2
unnamed: IC2.38 (GPIO_20), U2.2 (C)
unnamed: IC2.40 (GPIO_21), IC3.4 (DIN)
unnamed: IC2.41 (Run_1), SW1.1
unnamed: IC2.42 (Run_2), SW1.2
unnamed: IC3.13 (ROUT), IC4.9 (LIN)
unnamed: IC3.15 (LOUT), IC4.7 (RIN)
unnamed: IC4.3 (ROUT+), LS2.1
unnamed: IC4.4 (ROUT-), LS2.2
unnamed: IC4.5 (LOUT+), LS1.1
unnamed: IC4.6 (LOUT-), LS1.2
unnamed: IC5.5 (TX), R2.1
unnamed: J3.1, U3.6 (A4)
unnamed: J3.2, U3.12 (B6)
unnamed: J3.3, U3.7 (A5)
unnamed: J3.4, U3.11 (B7)
unnamed: J3.5, U3.8 (A6)
unnamed: J3.6, U3.13 (B5)
unnamed: J3.7, U3.9 (A7)
unnamed: J3.8, U3.14 (B4)
unnamed: R3.1, U2.4 (A)
unnamed: SW2.1, U1.14 (BTN)
unnamed: SW2.2, U1.13 (BTN)
unnamed: U3.18 (B0), U4.2 (DIN)

Board: 2 copper layers, 66.5 x 70.8 mm, 29 parts (4 on the bottom side), 53 nets.

## KiCad design Circuit/EmoRobot/EmoRobot.kicad_pcb

Board: 2 copper layers, 3 parts (0 on the bottom side), 8 nets, no tracks yet.

Parts:
IC1: RaspberryPiZeroW
IC2: PCM5102
U1: pam8403

Connections:
+5V: IC1.2 (DC_Power,5V), IC2.1 (VIN), U1.4 (vin)
GND: IC1.39 (GND), IC2.2 (GND), IC2.6 (SCK), U1.5 (gnd)
unnamed: IC1.35 (GPIO_19), IC2.3 (LRCK)
unnamed: IC1.40 (GPIO_21), IC2.4 (DIN)
unnamed: IC1.12 (GPIO_GEN1,GPIO_18), IC2.5 (BCK)
unnamed: IC2.15 (LOUT), U1.1 (L)
unnamed: IC2.13 (ROUT), U1.3 (R)
unnamed: IC2.12 (AGND), IC2.14 (AGND), U1.2 (T)

## Commit log

2024-10-25 sound mic screen motors in a rpi0w2
2024-10-25 Modelo v2 e o ano do rrrrrato
2024-10-27 dancing mediapipe
2024-10-29 DanceBeat Diana
2024-10-29 fix imports from display module
2024-10-29 motor and camera angles v2
2024-11-10 pose quantized
2024-11-13 Circuit included
2024-11-18 new packages
2024-11-26 Perigo Perigo Perigo
2024-11-28 eh hora de dancar clap fixed
2024-11-30 hand gesture with --mpipe
2024-12-02 more experiments with hand gesture recognition
